# IAR project RTOSDemo.ewp, settings and files
configuration Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX; HSE_VALUE=8000000
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ; board\; Libraries\CMSIS\Device\ST\STM32F4xx\Include; Libraries\STM32F4xx_StdPeriph_Driver\inc; Source\include; Source\portable\IAR\ARM_CM4F; Common\include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  OBJCOPY.OOCOutputFile: RTOSDemo.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: audio.c audio.h debug.c debug.h FreeRTOSConfig.h leds.c leds.h main.c pattern.c pattern.h stm32f4xx_it.c
  group Common Demo Source
    Common/Minimal/: BlockQ.c blocktim.c countsem.c death.c dynamic.c flash.c flash_timer.c GenQTest.c integer.c PollQ.c recmutex.c semtest.c sp_flop.c
  group FreeRTOS_Source
    Source/: list.c queue.c tasks.c timers.c
  group FreeRTOS_Source/Portable
    Source/portable/MemMang/: heap_2.c
    Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group ST_and_IAR_code/board
    board/: stm32f4_discovery.c
  group ST_and_IAR_code/startup
    startup/: startup_stm32f4xx.s system_stm32f4xx.c
  group ST_and_IAR_code/STM32F4xx_StdPeriph_Driver
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
